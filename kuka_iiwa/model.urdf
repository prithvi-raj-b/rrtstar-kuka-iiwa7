Commit message: Added rcm

File: kuka_iiwa/model.urdf (robot description, URDF)
Before this commit: robot lbr_iiwa, 9 links, 8 joints
Joints:
- joint needle_joint: origin xyz=0 0 0 rpy=-1.57079632679 3.14159265359 0 -> xyz=0 0 0.1 rpy=0 0 0
